# Keil uVision project RS485.uvprojx, settings and files
target RS485 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RS485 +hex
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\RS485;..\HARDWARE\LOCALBUS;..\HARDWARE\TIMER;..\DEMON\inc;..\HARDWARE\MODBUS_SLAVE;..\DUAGON\inc;..\MUE\base;..\MUE\md16;..\MUE\mdfl;..\MUE\muell;..\MUE\pd16;..\MUE\project
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/LOCALBUS/: localbus.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MODBUS_SLAVE/: modbus.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_tim.c
  group DUAGON
    ../DUAGON/src/: tcn_ap.c tcn_as.c tcn_demo.c tcn_lm.c tcn_lp.c tcn_ls.c tcn_ma.c tcn_mm.c tcn_str.c tcn_test.c
  group MUE
    ../MUE/base/: mue_acc.c mue_cal.c mue_md.c mue_osl.c mue_pd.c mue_sv.c mue_test.c
    ../MUE/pd16/: pd16_lp.c pd16_ls.c
    ../MUE/project/: mue_accr.c mue_bc.c tcn_bls.c
    ../MUE/muell/: muell_ls.c
    ../MUE/mdfl/: mdfl_lp.c mdfl_ls.c
    ../MUE/md16/: md16_lp.c md16_ls.c
